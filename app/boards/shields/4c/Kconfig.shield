## app/boards/shields/4c/Kconfig.shield
```kconfig
config SHIELD_4c_LEFT
    def_bool $(shields_list_contains,4c_left)
config SHIELD_4c_RIGHT
    def_bool $(shields_list_contains,4c_right)
```
